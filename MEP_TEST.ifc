Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: 0001
Time: 2022-05-11T09:20:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191031_1115(x64) - Exporter 20.3.3.0 - Alternate UI 20.3.3.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 11 09:20:35 2022 * Host: OMEN-10 * Database: C:\Users\Eipm02\AppData\Local\Temp\596faeb5-b650-4295-b14d-4948bf811dc9\7089bc4a-49a0-4d61-8c56-a9c9fbc91b1c\ifc * Database version: 5507 * Database creation date: Wed May 11 09:20:33 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 11 09:20:34 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 11 09:20:34 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 10.915 m
Pset_ProductRequirements - Category: Project Information
Identity Data - Organization Name: EiPM
Other - Category: Project Information; Project Number: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Identity Data - Organization Name: EiPM
Other - Category: Project Information; Project Number: 0001

# IfcBuildingStorey: Level:Extremo inicial 8 mm, AMM_ELEC_PS1_PK
LongName: AMM_ELEC_PS1_PK; Elevation: -3.565 m
Other - Category: Levels; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Building Story: yes; Name: AMM_ELEC_PS1_PK; Structural: no
Dimensions - Computation Height: 0 m
Pset_AirSideSystemInformation - Name: AMM_ELEC_PS1_PK
Pset_ProductRequirements - Name: AMM_ELEC_PS1_PK; Category: Levels
Constraints - Elevation: 7.35 m
Constraints(Type) - Elevation Base: Survey Point
Graphics(Type) - Color: 0; Line Pattern: Centro; Line Weight: 1; Symbol: M_Extremo inicial de nivel - Círculo: M_Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Extremo inicial 8 mm
Other(Type) - Category: Levels; Family Name: Level

# IfcDistributionPort (33)
Description: Flow; Group: L3J_SAN_PLUVIAL 4
Name | FlowDirection
InPort_5561637 | SINK
OutPort_5562856 | SOURCE
InPort_5561678 | SINK
OutPort_5561637 | SOURCE
InPort_5937388 | SINK
OutPort_5561678 | SOURCE
InPort_5562806 | SINK
OutPort_5562659 | SOURCE
InPort_5562854 | SINK
OutPort_5562806 | SOURCE
InPort_5562856 | SINK
OutPort_5562854 | SOURCE
InPort_5579301 | SINK
OutPort_5579131 | SOURCE
Port_5579287 | SOURCEANDSINK
InPort_5579287 | SOURCEANDSINK
OutPort_5937314 | SOURCEANDSINK
InPort_5936893 | SINK
OutPort_5579301 | SOURCE
InPort_5936895 | SINK
OutPort_5936893 | SOURCE
InPort_5937317 | SINK
OutPort_5936895 | SOURCE
InPort_5937238 | SOURCEANDSINK
2 x OutPort_5937387 | SOURCEANDSINK
Port_5937314 | SOURCEANDSINK
InPort_5937314 | SINK
OutPort_5937317 | SOURCE
Port_5937375 | SOURCEANDSINK
InPort_5937375 | SOURCEANDSINK
InPort_5937387 | SINK
OutPort_5937388 | SOURCE

# IfcFlowFitting: M_Codo - PVC - Serie 40:Norma PLUVIAL (3)
In: AMM_ELEC_PS1_PK
Type - Classification: 50.20.20.10 Canalitzacions d'aigües pluvials (Uniformat); Material: <Unnamed>
Type - Constraints - Default Elevation: 0 m
Type - Identity Data - Assembly Code: 50.20.20.10; Assembly Description: Canalitzacions d'aigües pluvials; OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings; Type Name: Norma PLUVIAL
Type - Mechanical - K Coefficient Table: Codo regular de 45, 90 y 180; Loss Method: K Coefficient from Table
Type - Other - Category: Pipe Fittings; Family Name: M_Codo - PVC - Serie 40; Nombre de tabla de consulta: M_Elbow - PVC - Sch 40
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Norma PLUVIAL; sets with these values: 2
XCA_TEST - Type: M_Codo - PVC - Serie 40: Norma PLUVIAL
Constraints - Level: Level: AMM_ELEC_PS1_PK
Graphics - Use Annotation Scale: no
Insulation - Insulation Thickness: 0 m
Mechanical - System Type: Piping System: L3J_SAN_PLUVIAL; System Classification: Sanitary; System Name: L3J_SAN_PLUVIAL 4
Mechanical - Flow - Pressure Drop: 0 Pa
Other - Family: M_Codo - PVC - Serie 40: Norma PLUVIAL; Family and Type: M_Codo - PVC - Serie 40: Norma PLUVIAL; Type: M_Codo - PVC - Serie 40: Norma PLUVIAL; Type Id: M_Codo - PVC - Serie 40: Norma PLUVIAL
Phasing - Phase Created: Projecte
Group: L3J_SAN_PLUVIAL 4
Name (M_Codo - PVC - Serie 40:Norma PLUVIAL:...) | Elevation from Level (m) | Ángulo (deg) | Centro a extremo (m) = Centro a extremo no encontrado (m) | Diámetro exterior de enchufe (m) = Diámetro exterior de enchufe no encontrado (m) | Diámetro nominal (m) = Maximum Size (m) = Minimum Size (m) | Longitud de enchufe (m) = Longitud de enchufe no encontrada (m) | Radio nominal (m) | Size | Tamaño de marca (m) | Volume (m3) | Overall Size | Ángulo 1 (deg) | Centro a etiqueta de extremo (m) | Longitud 1 (m) | Radio central (m) | Radio exterior de enchufe (m)
5561678 | -0.639104 | 44.9976 | 0.110478 | 0.152938 | 0.125 | 0.07395 | 0.0625 | 125ø-125ø | 0.0611753 | 0.00398922 | 125 mmø-125 mmø | 45 | 0.110478 | 0.105951 | 0.0881919 | 0.0764691
5562854 | -0.632711 | 89.4286 | 0.12776 | 0.135792 | 0.11 | 0.0624977 | 0.055 | 110ø-110ø | 0.0543169 | 0.00336283 | 110 mmø-110 mmø | 90 | 0.130506 | 0.130506 | 0.0686898 | 0.0678961
5936893 | -0.622832 | 89.469 | 0.12776 | 0.135792 | 0.11 | 0.0624977 | 0.055 | 110ø-110ø | 0.0543169 | 0.00336353 | 110 mmø-110 mmø | 90 | 0.130554 | 0.130554 | 0.0686898 | 0.0678961

# IfcFlowFitting: M_Reductor - PVC - Serie 40 - DWV:Norma PLUVIAL (2)
In: AMM_ELEC_PS1_PK
Type - Classification: 50.20.20.10 Canalitzacions d'aigües pluvials (Uniformat); Material: <Unnamed>
Type - Constraints - Default Elevation: 0 m
Type - Identity Data - Assembly Code: 50.20.20.10; Assembly Description: Canalitzacions d'aigües pluvials; OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings; Type Name: Norma PLUVIAL
Type - Mechanical - Loss Method: Not Defined
Type - Other - Category: Pipe Fittings; Family Name: M_Reductor - PVC - Serie 40 - DWV; Nombre de tabla de consulta: M_Reducer - PVC - Sch 40 - DWV
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Norma PLUVIAL; sets with these values: 2
XCA_TEST - Type: M_Reductor - PVC - Serie 40 - DWV: Norma PLUVIAL
Constraints - Level: Level: AMM_ELEC_PS1_PK
Dimensions - Area: 0.0514647 m2; Longitud: 0.133546 m; Maximum Size: 0.125 m; Minimum Size: 0.11 m; Size: 125ø-110ø
Graphics - Use Annotation Scale: no
Insulation - Insulation Thickness: 0 m; Overall Size: 125 mmø-110 mmø
Mechanical - System Type: Piping System: L3J_SAN_PLUVIAL; System Classification: Sanitary; System Name: L3J_SAN_PLUVIAL 4
Mechanical - Flow - Pressure Drop: 0 Pa
Other - Desfase de altura: 3.048 m; Desfase de anchura: 3.048 m; Diámetro nominal máx. 12: 0.125 m; Diámetro nominal mín. 12: 0.11 m; Family: M_Reductor - PVC - Serie 40 - DWV: Norma PLUVIAL; Family and Type: M_Reductor - PVC - Serie 40 - DWV: Norma PLUVIAL; Type: M_Reductor - PVC - Serie 40 - DWV: Norma PLUVIAL; Type Id: M_Reductor - PVC - Serie 40 - DWV: Norma PLUVIAL; Visibilidad 1: no
Phasing - Phase Created: Projecte
Group: L3J_SAN_PLUVIAL 4
Name (M_Reductor - PVC - Serie 40 - DWV:Norma PLUVIAL:...) | Elevation from Level (m) | Diámetro de entrada de enchufe 1 (m) | Diámetro de entrada de enchufe 2 (m) | Diámetro exterior de enchufe 1 (m) | Diámetro exterior de enchufe 2 (m) | Diámetro exterior de unión 1 (m) | Diámetro exterior de unión 2 (m) | Diámetro nominal 1 (m) | Diámetro nominal 2 (m) | Grosor de pared 1 (m) | Grosor de pared 2 (m) | OffsetHeight (m) = OffsetWidth (m) = Profundidad de enchufe 1 (m) = Radio nominal 1 (m) | Profundidad de enchufe 2 (m) = Radio nominal 2 (m) | Tamaño de marca 1 (m) | Tamaño de marca 2 (m) | Volume (m3) | Radio exterior de enchufe 1 (m) | Radio exterior de enchufe 2 (m) | Radio exterior de unión 1 (m) | Radio exterior de unión 2 (m) | Visibilidad 2 | Visibilidad 3
5562856 | -0.635351 | 0.139426 | 0.123826 | 0.150974 | 0.134774 | 0.139128 | 0.123528 | 0.125 | 0.11 | 0.00577422 | 0.00547422 | 0.0625 | 0.055 | 0.0556512 | 0.0494112 | 0.00212102 | 0.0754871 | 0.0673871 | 0.0695641 | 0.0617641 | yes | no
5936895 | -0.624042 | 0.123826 | 0.139426 | 0.134774 | 0.150974 | 0.123528 | 0.139128 | 0.11 | 0.125 | 0.00547422 | 0.00577422 | 0.055 | 0.0625 | 0.0494112 | 0.0556512 | 0.00212101 | 0.0673871 | 0.0754871 | 0.0617641 | 0.0695641 | no | yes

# IfcFlowFitting: M_Te - PVC - Serie 40:Norma PLUVIAL (2)
In: AMM_ELEC_PS1_PK
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 m
Type - Identity Data - Assembly Code: 50.20.20.10; Assembly Description: Canalitzacions d'aigües pluvials; OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings; Type Name: Norma PLUVIAL
Type - Mechanical - Loss Method: K Coefficient from Table; K Coefficient Table: Te
Type - Other - Category: Pipe Fittings; Family Name: M_Te - PVC - Serie 40; Nombre de tabla de consulta: M_Tee - PVC - Sch 40
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 50.20.20.10 Canalitzacions d'aigües pluvials (Uniformat); Group: L3J_SAN_PLUVIAL 4
Pset_DistributionFlowElementCommon - Reference: Norma PLUVIAL; sets with these values: 2
XCA_TEST - Type: M_Te - PVC - Serie 40: Norma PLUVIAL
Constraints - Level: Level: AMM_ELEC_PS1_PK
Dimensions - Centro a extremo: 0.14276 m; Diámetro exterior de enchufe: 0.15274 m; Diámetro nominal: 0.125 m; Maximum Size: 0.125 m; Minimum Size: 0.125 m; Radio nominal: 0.0625 m; Size: 125ø-125ø-125ø; Tamaño de marca: 0.0610959 m
Graphics - Use Annotation Scale: no
Insulation - Insulation Thickness: 0 m; Overall Size: 125 mmø-125 mmø-125 mmø
Mechanical - System Type: Piping System: L3J_SAN_PLUVIAL; System Classification: Sanitary; System Name: L3J_SAN_PLUVIAL 4
Other - Family: M_Te - PVC - Serie 40: Norma PLUVIAL; Family and Type: M_Te - PVC - Serie 40: Norma PLUVIAL; Radio exterior de enchufe: 0.0763699 m; Type: M_Te - PVC - Serie 40: Norma PLUVIAL; Type Id: M_Te - PVC - Serie 40: Norma PLUVIAL
Phasing - Phase Created: Projecte
Name (M_Te - PVC - Serie 40:Norma PLUVIAL:...) | Elevation from Level (m) | Ángulo (deg) = Ángulo 1 (deg) | Volume (m3) | Centro a etiqueta de extremo (m)
5937314 | -0.637362 | 45.0028 | 0.00845649 | 0.184361
5937387 | -0.662411 | 31.0026 | 0.0128316 | 0.275357

# IfcFlowSegment: Pipe Types:L3J_TUBERIA_SANEJAMENT_PVC PLUVIAL (8)
In: AMM_ELEC_PS1_PK
Type - Pset_ProductRequirements - Category: Pipes
Type - Identity Data - Assembly Code: 50.20.20.10; Assembly Description: Canalitzacions d'aigües pluvials; Description: Canonades per a xarxa de sanejament de PVC; Type Name: L3J_TUBERIA_SANEJAMENT_PVC PLUVIAL
Type - Other - Category: Pipes; Family Name: Pipe Types
Classification: 50.20.20.10 Canalitzacions d'aigües pluvials (Uniformat); Group: L3J_SAN_PLUVIAL 4
Constraints - Horizontal Justification: Center; Reference Level: Level: AMM_ELEC_PS1_PK; Vertical Justification: Middle
Dimensions - sets with these values: 2
Insulation - Insulation Thickness: 0 m; sets with these values: 2
Mechanical - Connection Type: Generic; Material: PVC-C; Pipe Segment: PVC-C - L3J; Roughness: 0.0000015 m; Schedule/Type: Pipe Schedule Types: L3J; System Classification: Sanitary; System Name: L3J_SAN_PLUVIAL 4; System Type: Piping System: L3J_SAN_PLUVIAL
Mechanical - Flow - Fixture Units: 0; sets with these values: 2
Other - Family: Pipe Types: L3J_TUBERIA_SANEJAMENT_PVC PLUVIAL; Family and Type: Pipe Types: L3J_TUBERIA_SANEJAMENT_PVC PLUVIAL; Type: Pipe Types: L3J_TUBERIA_SANEJAMENT_PVC PLUVIAL; Type Id: Pipe Types: L3J_TUBERIA_SANEJAMENT_PVC PLUVIAL; sets with these values: 2
Phasing - Phase Created: Projecte; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: L3J_TUBERIA_SANEJAMENT_PVC PLUVIAL; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.0000015 m
XCA_TEST - Type: Pipe Types: L3J_TUBERIA_SANEJAMENT_PVC PLUVIAL
Name (Pipe Types:L3J_TUBERIA_SANEJAMENT_PVC PLUVIAL:...) | Bottom Elevation (m) | End Middle Elevation (m) | Middle Elevation (m) = Start Middle Elevation (m) | Slope | Top Elevation (m) | Inside Diameter (m) | Dimensions, Length (m) = Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) | Outside Diameter (m) = Diameter (m) | Size | Overall Size | Area (m2) | Invert Elevation (m) = InvertElevation (m) | Section | Relative Roughness | Constraints, sets with these values = Mechanical, sets with these values
5561637 | -0.700496 | -0.637999 | -0.635351 | 1 | -0.572855 | 0.1188 | 0.26477 | 0.125 | 125ø | 125 mmø | 0.103975 | -4.2624 | 48 | 0.0000126263
5562806 | -0.502206 | -0.502205 | -0.0195705 |  | -0.0195697 | 0.1046 | 0.482635 | 0.11 | 110ø | 110 mmø | 0.166787 | -4.06721 | 41 | 0.0000143403 | 2
5579287 | -0.709908 | -0.647411 | -0.63907 | 0.926727 | -0.576573 | 0.1188 | 0.9 | 0.125 | 125ø | 125 mmø | 0.353429 | -4.27181 | 62 | 0.0000126263 | 2
5579301 | -0.492278 | -0.492278 | -0.0195705 |  | -0.0195705 | 0.1046 | 0.472708 | 0.11 | 110ø | 110 mmø | 0.163356 | -4.05728 | 50 | 0.0000143403 | 2
5937238 | -0.832443 | -0.769946 | -0.665142 | 0.991744 | -0.602645 | 0.1188 | 10.5682 | 0.125 | 125ø | 125 mmø | 4.15012 | -4.39434 | 33 | 0.0000126263 | 2
5937317 | -0.698151 | -0.635653 | -0.625279 | 0.926727 | -0.562782 | 0.1188 | 1.11948 | 0.125 | 125ø | 125 mmø | 0.439618 | -4.26005 | 57 | 0.0000126263 | 2
5937375 | -0.719093 | -0.640208 | -0.656607 | 2.10829 | -0.577722 | 0.1188 | 0.77799 | 0.125 | 125ø | 125 mmø | 0.305516 | -4.28099 | 64 | 0.0000126263 | 2
5937388 | -0.722177 | -0.65968 | -0.640208 | 0.991744 | -0.577712 | 0.1188 | 1.96351 | 0.125 | 125ø | 125 mmø | 0.771068 | -4.28408 | 48 | 0.0000126263 | 2

# IfcFlowTerminal: L3J_BUNERA:BUNERA 110 (2)
In: AMM_ELEC_PS1_PK
Type - Classification: 50.20.10.10 Equips de mesura i control d'evacuació d'aigües (Uniformat); Material: <Unnamed> (2)
Type - Constraints - Default Elevation: 0 m
Type - Dimensions - MSI_MEP_Costat: 0.25 m; MSI_MEP_Diametre Sortida: 0.11 m
Type - Identity Data - Assembly Code: 50.20.10.10; Assembly Description: Equips de mesura i control d'evacuació d'aigües; Description: BUNERA; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: BUNERA 110
Type - Other - Category: Plumbing Fixtures; Family Name: L3J_BUNERA; L3J_DIAMETRE (Sanejament): Ø110; L3J_SIMBOL: BU; L3J_UNITATS DE DESGÜAS (CTE-DB-HS): --
Type - Visibility - L3J_Apareix en Taula d'Aparells Sanitaris: yes; L3J_Apareix en Taula de Dimensions de Canonades: no
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: BUNERA 110; sets with these values: 2
XCA_TEST - Type: L3J_BUNERA: BUNERA 110
Constraints - Level: Level: AMM_ELEC_PS1_PK; Elevation from Level: 0 m; Host: Level : AMM_ELEC_PS1_PK; Offset from Host: 0 m
Dimensions - Area: 0.0882634 m2; Volume: 0.00132002 m3
Mechanical - System Type: Piping System: L3J_SAN_PLUVIAL; System Classification: Sanitary; System Name: L3J_SAN_PLUVIAL 4
Other - Family: L3J_BUNERA: BUNERA 110; Family and Type: L3J_BUNERA: BUNERA 110; Type: L3J_BUNERA: BUNERA 110; Type Id: L3J_BUNERA: BUNERA 110
Phasing - Phase Created: Projecte
Secondary End - L3J_BUNERA SIFÓNICA: no
Group: L3J_SAN_PLUVIAL 4
Name (L3J_BUNERA:BUNERA 110:...) | Mark
5562659 | 1893
5579131 | 1896 | Material: <Unnamed>

# IfcSystem: L3J_SAN_PLUVIAL, L3J_SAN_PLUVIAL 4
Other - Category: Piping Systems; Family: Piping System: L3J_SAN_PLUVIAL; Family and Type: Piping System: L3J_SAN_PLUVIAL; Type: Piping System: L3J_SAN_PLUVIAL; Type Id: Piping System: L3J_SAN_PLUVIAL
Mechanical - Fixture Units: 0; Number of Elements: 7; System Name: L3J_SAN_PLUVIAL 4
